# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ST; STM32F469xx; USE_FLOATING_POINT; USE_OS_SYSTICK; USE_BPP=16
  ICCARM.IExtraOptions: --diag_warning Pe167
  ICCARM.CCIncludePath2: ..\..\generated\images\include; ..\..\generated\fonts\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\platform\os; ..\..\gui\include; ..\..\target\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\cortex-m; ..\bsp\include\platform\cortex-m\CMSIS; ..\bsp\include\platform\hal\mcu\stm32f4cube; ..\bsp\include\platform\hal\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\bsp\include\platform\hal\mcu\stm32f4cube\CMSIS; ..\bsp\include; ..\bsp\include\bsp; ..\bsp\source\vendor\STM32469I-Discovery; ..\os\FreeRTOS7.6.0\Source\include; ..\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m4f\IAR8.x\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_30_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp Font_verdana_60_4bpp_0.cpp Font_verdana_8_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_30_4bpp.cpp Kerning_verdana_40_4bpp.cpp Kerning_verdana_60_4bpp.cpp Kerning_verdana_8_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_30_4bpp.cpp Table_verdana_40_4bpp.cpp Table_verdana_60_4bpp.cpp Table_verdana_8_4bpp.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: DigitTemplateBase.cpp
  group Application/generated/gui_generated/screen_main_screen
    ../../generated/gui_generated/src/screen_main_screen/: Screen_MainViewBase.cpp
  group Application/generated/gui_generated/screen_module1_data_screen
    ../../generated/gui_generated/src/screen_module1_data_screen/: Screen_Module1_DataViewBase.cpp
  group Application/generated/gui_generated/screen_module1_graph_screen
    ../../generated/gui_generated/src/screen_module1_graph_screen/: Screen_Module1_GraphViewBase.cpp
  group Application/generated/gui_generated/screen_module1_info_screen
    ../../generated/gui_generated/src/screen_module1_info_screen/: Screen_Module1_InfoViewBase.cpp
  group Application/generated/gui_generated/screen_module1_settings_screen
    ../../generated/gui_generated/src/screen_module1_settings_screen/: Screen_Module1_SettingsViewBase.cpp
  group Application/generated/gui_generated/screen_module1_signals_screen
    ../../generated/gui_generated/src/screen_module1_signals_screen/: Screen_Module1_SignalsViewBase.cpp
  group Application/generated/gui_generated/screen_uart_rx_debug_screen
    ../../generated/gui_generated/src/screen_uart_rx_debug_screen/: Screen_UART_RX_DebugViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: background.cpp BitmapDatabase.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: blue_buttons_round_edge_medium.cpp blue_buttons_round_edge_medium_pressed.cpp blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_buttons_round_icon_button.cpp blue_buttons_round_icon_button_pressed.cpp blue_check_buttons_check_mark_active.cpp blue_check_buttons_check_mark_inactive.cpp blue_check_buttons_check_mark_normal.cpp blue_check_buttons_check_mark_pressed.cpp Blue_Check_buttons_custom_Check_mark_fill_minus.cpp Blue_Check_buttons_custom_Check_mark_fill_plus.cpp Blue_Slider_Horizontal_Small_Indicators_slider_horizontal_small_round_knob.cpp Blue_Slider_Horizontal_Small_slider_horizontal_small_round_back.cpp Blue_Slider_Horizontal_Small_slider_horizontal_small_round_fill.cpp blue_togglebars_toggle_round_small_button_off.cpp blue_togglebars_toggle_round_small_button_on.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui
    ../../gui/src/: init.cpp uart_packet.cpp utilities.cpp
  group Application/gui/common
    ../../gui/src/common/: AbstractGraph.cpp FrontendApplication.cpp Graph.cpp GraphLine.cpp
  group Application/gui/containers
    ../../gui/src/containers/: DigitTemplate.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/screen_main_screen
    ../../gui/src/screen_main_screen/: Screen_MainPresenter.cpp Screen_MainView.cpp
  group Application/gui/screen_module1_data_screen
    ../../gui/src/screen_module1_data_screen/: Screen_Module1_DataPresenter.cpp Screen_Module1_DataView.cpp
  group Application/gui/screen_module1_graph_screen
    ../../gui/src/screen_module1_graph_screen/: Screen_Module1_GraphPresenter.cpp Screen_Module1_GraphView.cpp
  group Application/gui/screen_module1_info_screen
    ../../gui/src/screen_module1_info_screen/: Screen_Module1_InfoPresenter.cpp Screen_Module1_InfoView.cpp
  group Application/gui/screen_module1_settings_screen
    ../../gui/src/screen_module1_settings_screen/: Screen_Module1_SettingsPresenter.cpp Screen_Module1_SettingsView.cpp
  group Application/gui/screen_module1_signals_screen
    ../../gui/src/screen_module1_signals_screen/: Screen_Module1_SignalsPresenter.cpp Screen_Module1_SignalsView.cpp
  group Application/gui/screen_uart_rx_debug_screen
    ../../gui/src/screen_uart_rx_debug_screen/: Screen_UART_RX_DebugPresenter.cpp Screen_UART_RX_DebugView.cpp
  group Application/main
    ../: main.cpp
  group CubeF4/Board
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group CubeF4/MCU
    ../bsp/source/platform/hal/mcu/stm32f4cube/IAR/: startup_stm32f469xx.s
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ./: stm32f4xx_it.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: Buttons.cpp KeySampler.cpp OTM8009TouchController.cpp
  group TouchGFXPort/MCU
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
