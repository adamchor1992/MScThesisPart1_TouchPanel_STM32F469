# Keil uVision project application.uvproj, settings and files
target Internal flash and NOR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F439NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: application +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: ST STM32F469xx USE_OS_SYSTICK USE_BPP=16
  c include: ../../touchgfx/framework/include;../../gui/include;../../target/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/hal/mcu/stm32f4cube;../bsp/include/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver;../bsp/include/platform/hal/mcu/stm32f4cube/CMSIS;../bsp/include;../bsp/include/bsp;../bsp/source/vendor/STM32469I-Discovery;../os/FreeRTOS7.6.0/Source/include;../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F
  asm include: ../../platform/os
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Flash.sct
  group Startup
    ../bsp/source/platform/hal/mcu/stm32f4cube/Keil/: startup_stm32f469xx.s
    ../: main.cpp
  group TouchGFXHAL
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: OTM8009TouchController.cpp Buttons.cpp KeySampler.cpp
  group HAL
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_crc.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
  group OS
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/common/: abstractgraph.cpp frontendapplication.cpp graph.cpp graphline.cpp
    ../../gui/src/containers/: digittemplate.cpp
    ../../gui/src/: init.cpp uart_packet.cpp utilities.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/screen_main_screen/: screen_mainpresenter.cpp screen_mainview.cpp
    ../../gui/src/screen_module1_data_screen/: screen_module1_datapresenter.cpp screen_module1_dataview.cpp
    ../../gui/src/screen_module1_graph_screen/: screen_module1_graphpresenter.cpp screen_module1_graphview.cpp
    ../../gui/src/screen_module1_info_screen/: screen_module1_infopresenter.cpp screen_module1_infoview.cpp
    ../../gui/src/screen_module1_settings_screen/: screen_module1_settingspresenter.cpp screen_module1_settingsview.cpp
    ../../gui/src/screen_module1_signals_screen/: screen_module1_signalspresenter.cpp screen_module1_signalsview.cpp
    ../../gui/src/screen_module2_data_screen/: screen_module2_datapresenter.cpp screen_module2_dataview.cpp
    ../../gui/src/screen_module2_graph_screen/: screen_module2_graphpresenter.cpp screen_module2_graphview.cpp
    ../../gui/src/screen_module2_info_screen/: screen_module2_infopresenter.cpp screen_module2_infoview.cpp
    ../../gui/src/screen_module2_settings_screen/: screen_module2_settingspresenter.cpp screen_module2_settingsview.cpp
    ../../gui/src/screen_module2_signals_screen/: screen_module2_signalspresenter.cpp screen_module2_signalsview.cpp
    ../../gui/src/screen_module3_data_screen/: screen_module3_datapresenter.cpp screen_module3_dataview.cpp
    ../../gui/src/screen_module3_graph_screen/: screen_module3_graphpresenter.cpp screen_module3_graphview.cpp
    ../../gui/src/screen_module3_info_screen/: screen_module3_infopresenter.cpp screen_module3_infoview.cpp
    ../../gui/src/screen_module3_settings_screen/: screen_module3_settingspresenter.cpp screen_module3_settingsview.cpp
    ../../gui/src/screen_module3_signals_screen/: screen_module3_signalspresenter.cpp screen_module3_signalsview.cpp
    ../../gui/src/screen_uart_rx_debug_screen/: screen_uart_rx_debugpresenter.cpp screen_uart_rx_debugview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_verdana_20_4bpp_0.cpp font_verdana_30_4bpp_0.cpp font_verdana_40_4bpp_0.cpp font_verdana_60_4bpp_0.cpp font_verdana_8_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_30_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdana_60_4bpp.cpp kerning_verdana_8_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_30_4bpp.cpp table_verdana_40_4bpp.cpp table_verdana_60_4bpp.cpp table_verdana_8_4bpp.cpp
    ../../generated/images/src/: background.cpp bitmapdatabase.cpp
    ../../generated/images/src/__designer/: blue_buttons_round_edge_medium.cpp blue_buttons_round_edge_medium_pressed.cpp blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_buttons_round_icon_button.cpp blue_buttons_round_icon_button_pressed.cpp blue_check_buttons_check_mark_active.cpp blue_check_buttons_check_mark_inactive.cpp blue_check_buttons_check_mark_normal.cpp blue_check_buttons_check_mark_pressed.cpp blue_check_buttons_custom_check_mark_fill_minus.cpp blue_check_buttons_custom_check_mark_fill_plus.cpp blue_slider_horizontal_small_indicators_slider_horizontal_small_round_knob.cpp blue_slider_horizontal_small_slider_horizontal_small_round_back.cpp blue_slider_horizontal_small_slider_horizontal_small_round_fill.cpp blue_togglebars_toggle_round_small_button_off.cpp blue_togglebars_toggle_round_small_button_on.cpp
    ../../generated/gui_generated/src/containers/: digittemplatebase.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/screen_main_screen/: screen_mainviewbase.cpp
    ../../generated/gui_generated/src/screen_module1_data_screen/: screen_module1_dataviewbase.cpp
    ../../generated/gui_generated/src/screen_module1_graph_screen/: screen_module1_graphviewbase.cpp
    ../../generated/gui_generated/src/screen_module1_info_screen/: screen_module1_infoviewbase.cpp
    ../../generated/gui_generated/src/screen_module1_settings_screen/: screen_module1_settingsviewbase.cpp
    ../../generated/gui_generated/src/screen_module1_signals_screen/: screen_module1_signalsviewbase.cpp
    ../../generated/gui_generated/src/screen_module2_data_screen/: screen_module2_dataviewbase.cpp
    ../../generated/gui_generated/src/screen_module2_graph_screen/: screen_module2_graphviewbase.cpp
    ../../generated/gui_generated/src/screen_module2_info_screen/: screen_module2_infoviewbase.cpp
    ../../generated/gui_generated/src/screen_module2_settings_screen/: screen_module2_settingsviewbase.cpp
    ../../generated/gui_generated/src/screen_module2_signals_screen/: screen_module2_signalsviewbase.cpp
    ../../generated/gui_generated/src/screen_module3_data_screen/: screen_module3_dataviewbase.cpp
    ../../generated/gui_generated/src/screen_module3_graph_screen/: screen_module3_graphviewbase.cpp
    ../../generated/gui_generated/src/screen_module3_info_screen/: screen_module3_infoviewbase.cpp
    ../../generated/gui_generated/src/screen_module3_settings_screen/: screen_module3_settingsviewbase.cpp
    ../../generated/gui_generated/src/screen_module3_signals_screen/: screen_module3_signalsviewbase.cpp
    ../../generated/gui_generated/src/screen_uart_rx_debug_screen/: screen_uart_rx_debugviewbase.cpp
