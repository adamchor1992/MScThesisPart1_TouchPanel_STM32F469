# Keil uVision project application.uvprojx, settings and files
target Internal flash and NOR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F439NI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: application +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: ST STM32F469xx USE_OS_SYSTICK USE_BPP=16
  c include: ../../touchgfx/framework/include;../../gui/include;../../target/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/hal/mcu/stm32f4cube;../bsp/include/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver;../bsp/include/platform/hal/mcu/stm32f4cube/CMSIS;../bsp/include;../bsp/include/bsp;../bsp/source/vendor/STM32469I-Discovery;../os/FreeRTOS7.6.0/Source/include;../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F
  asm include: ../../platform/os
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Flash.sct
  group Startup
    ../bsp/source/platform/hal/mcu/stm32f4cube/Keil/: startup_stm32f469xx.s
    ../: main.cpp
  group TouchGFXHAL
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: OTM8009TouchController.cpp Buttons.cpp KeySampler.cpp
  group HAL
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_crc.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
  group OS
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/common/: abstractgraph.cpp frontendapplication.cpp graph.cpp graphline.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/screen_main_screen/: screen_mainpresenter.cpp screen_mainview.cpp
    ../../gui/src/screen_module1_screen/: screen_module1presenter.cpp screen_module1view.cpp
    ../../gui/src/screen_module2_screen/: screen_module2presenter.cpp screen_module2view.cpp
    ../../gui/src/screen_module3_screen/: screen_module3presenter.cpp screen_module3view.cpp
    ../../gui/src/screen_uart_screen/: screen_uartpresenter.cpp screen_uartview.cpp
    ../../gui/src/template_screen/: templatepresenter.cpp templateview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp font_verdana_10_4bpp.cpp font_verdana_20_4bpp.cpp font_verdana_40_4bpp.cpp fontgetters.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp
    ../../generated/images/src/: background.cpp bitmapdatabase.cpp
    ../../generated/images/src/__designer/: blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_check_buttons_check_mark_active.cpp blue_check_buttons_check_mark_inactive.cpp blue_check_buttons_check_mark_normal.cpp blue_check_buttons_check_mark_pressed.cpp blue_slider_horizontal_medium_indicators_slider_round_nob.cpp blue_slider_horizontal_medium_slider_round_back.cpp blue_slider_horizontal_medium_slider_round_fill.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/screen_main_screen/: screen_mainviewbase.cpp
    ../../generated/gui_generated/src/screen_module1_screen/: screen_module1viewbase.cpp
    ../../generated/gui_generated/src/screen_module2_screen/: screen_module2viewbase.cpp
    ../../generated/gui_generated/src/screen_module3_screen/: screen_module3viewbase.cpp
    ../../generated/gui_generated/src/screen_uart_screen/: screen_uartviewbase.cpp
    ../../generated/gui_generated/src/template_screen/: templateviewbase.cpp
software components: CMSIS:CORE 5.1.2
